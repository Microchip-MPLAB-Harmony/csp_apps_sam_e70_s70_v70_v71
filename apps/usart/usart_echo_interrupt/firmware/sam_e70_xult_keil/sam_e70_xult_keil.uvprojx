# Keil uVision project sam_e70_xult_keil.uvprojx, settings and files
target sam_e70_xult_keil (6180000::V6.18::ARMCLANG)
  device: ATSAME70Q21B Microchip
  pack: Microchip.SAME70_DFP.4.9.129
  cpu: IRAM(0x20400000,0x00060000) IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: sam_e70_xult_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_e70_xult_keil;..\src\packs\ATSAME70Q21B_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS
  scatter file: ..\src\config\sam_e70_xult_keil\sam_e70_xult_keil.sct
  group Harmony3
    ../src/config/sam_e70_xult_keil/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h initialization.c interrupts.c exceptions.c startup_keil.c
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h fuses.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
    ../src/packs/ATSAME70Q21B_DFP/instance/: acc.h aes.h afec0.h afec1.h chipid.h dacc.h efc.h fuses.h gmac.h gpbr.h hsmci.h i2sc0.h i2sc1.h icm.h isi.h matrix.h mcan0.h mcan1.h pioa.h piob.h pioc.h piod.h pioe.h pmc.h pwm0.h pwm1.h qspi.h rstc.h rswdt.h rtc.h rtt.h smc.h spi0.h spi1.h ssc.h supc.h tc0.h tc1.h tc2.h tc3.h trng.h twihs0.h twihs1.h twihs2.h uart0.h uart1.h uart2.h uart3.h uart4.h usart0.h usart1.h usart2.h usbhs.h utmi.h wdt.h xdmac.h
    ../src/packs/ATSAME70Q21B_DFP/: same70q21b.h
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
    ../src/config/sam_e70_xult_keil/peripheral/clk/: plib_clk.h plib_clk.c
    ../src/config/sam_e70_xult_keil/peripheral/pio/: plib_pio.h plib_pio.c
    ../src/config/sam_e70_xult_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm7.h mpu_armv7.h cachel1_armv7.h
    ../src/config/sam_e70_xult_keil/peripheral/efc/: plib_efc.h plib_efc.c
    ../src/config/sam_e70_xult_keil/peripheral/usart/: plib_usart_common.h plib_usart1.h plib_usart1.c
    ../src/: main.c
    ../src/config/sam_e70_xult_keil/stdio/: keil_monitor.c
