# Keil uVision project usart_echo_interrupt_sam_e70_xult_keil.uvprojx, settings and files
target sam_e70_xult_keil (6130001::V6.13.1::.\ARMCLANG)
  device: ATSAME70Q21B Microchip
  pack: Atmel.SAME70_DFP.2.4.166
  cpu: IRAM(0x20400000,0x00060000) IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: sam_e70_xult_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_e70_xult_keil;..\src\packs\ATSAME70Q21B_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\src\config\sam_e70_xult_keil\sam_e70_xult_keil.sct
  group Harmony3
    ../src/config/sam_e70_xult_keil/: device_cache.h toolchain_specifics.h definitions.h device.h initialization.c interrupts.c exceptions.c startup_keil.c
    ../src/config/sam_e70_xult_keil/peripheral/clk/: plib_clk.h plib_clk.c
    ../src/config/sam_e70_xult_keil/peripheral/pio/: plib_pio.h plib_pio.c
    ../src/config/sam_e70_xult_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
    ../src/packs/ATSAME70Q21B_DFP/: atsame70q21b.h
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm7.h mpu_armv7.h cachel1_armv7.h
    ../src/config/sam_e70_xult_keil/peripheral/efc/: plib_efc.h plib_efc.c
    ../src/config/sam_e70_xult_keil/peripheral/usart/: plib_usart_common.h plib_usart1.h plib_usart1.c
    ../src/: main.c
    ../src/config/sam_e70_xult_keil/stdio/: keil_monitor.c
