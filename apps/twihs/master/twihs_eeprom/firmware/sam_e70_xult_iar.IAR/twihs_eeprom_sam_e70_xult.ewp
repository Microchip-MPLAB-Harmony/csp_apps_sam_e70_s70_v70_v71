# IAR project twihs_eeprom_sam_e70_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_e70_xult_iar; ..\src\packs\ATSAME70Q21B_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sam_e70_xult_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_e70_xult_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files/config/sam_e70_xult_iar
    ../src/config/sam_e70_xult_iar/: device_cache.h toolchain_specifics.h definitions.h device.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/clk
    ../src/config/sam_e70_xult_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/pio
    ../src/config/sam_e70_xult_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/nvic
    ../src/config/sam_e70_xult_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/twihs
    ../src/config/sam_e70_xult_iar/peripheral/twihs/: plib_twihs_master.h plib_twihs0.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/efc
    ../src/config/sam_e70_xult_iar/peripheral/efc/: plib_efc.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP
    ../src/packs/ATSAME70Q21B_DFP/: atsame70q21b.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/component
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/pio
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm7.h mpu_armv7.h cachel1_armv7.h
  group Harmony3/Source Files
    ../src/: main.c
  group Harmony3/Source Files/config/sam_e70_xult_iar
    ../src/config/sam_e70_xult_iar/: initialization.c interrupts.c exceptions.c startup_iar.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/stdio
    ../src/config/sam_e70_xult_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/clk
    ../src/config/sam_e70_xult_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/pio
    ../src/config/sam_e70_xult_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/nvic
    ../src/config/sam_e70_xult_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/twihs
    ../src/config/sam_e70_xult_iar/peripheral/twihs/: plib_twihs0.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/efc
    ../src/config/sam_e70_xult_iar/peripheral/efc/: plib_efc.c
  group Harmony3/Linker File
    ../src/config/sam_e70_xult_iar/: flash.icf
